# Keil uVision project BluetoothData.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BluetoothData +hex
  c flags: Optimize=8 SizeSpeed=1
  group Src
    ./: STARTUP.A51 main.c DHT11.c lcd.c Usart1.c
  group README
    ./README/: readme.txt
